<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\test_led_light.ewp</path>
  </project>
  <batchBuild />
</workspace>
